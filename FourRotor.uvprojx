# Keil uVision project FourRotor.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FourRotor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\user;.\user\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c nvic.c systick.c led.c breatheLed.c usart.c i2c_moni.c mpu6050_i2cmoni.c dmp_exti.c moto_pwm.c spi.c nRF.c deal_datapacket.c checksignal.c control.c
  group eMPL
    ./user/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu_dmp_useapi.c
    ./user/: ANO_DT.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
